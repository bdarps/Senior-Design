# Keil uVision project AtmelStart.uvprojx, settings and files
target ATSAMD20J18 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ATSAMD20J18 Microchip
  pack: Keil.SAMD20_DFP.1.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AtmelStart
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\samd20\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
